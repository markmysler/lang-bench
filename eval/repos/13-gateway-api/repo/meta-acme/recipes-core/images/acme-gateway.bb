SUMMARY = "Acme gateway image"
inherit core-image
IMAGE_INSTALL += "acme-firmware sensorlink"
